# Keil uVision project uart.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./src/: AFIO_program.c DMA_program.c EXTI_program.c GPIO_program.c main.c NVIC_program.c OS_program.c RCC_program.c SPI_program.c SYSTICK_program.c uart.c uart_PBcfg.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
